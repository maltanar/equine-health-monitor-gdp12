# IAR project tmp006.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\common\CMSIS\Include; ..\common\EFM32TG\Include; ..\common\emlib\inc; ..\common\drivers; ..\common\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tmp006.bin
  ILINK.IlinkOutputFile: tmp006.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32TG840F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  group Application
    ./: alarm.c alarm.h debug_output_control.h main.cpp sensor.cpp sensor.h temperaturesensor.cpp temperaturesensor.h
  group EM framework/BSP
    ../common/bsp/: trace.c
  group EM framework/CMSIS
    ../common/EFM32TG/Source/: startup_efm32tg.s system_efm32tg.c
  group EM framework/Drivers
    ../common/drivers/: rtc.c
  group EM framework/emlib
    ../common/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_i2c.c em_rtc.c em_system.c
