# IAR project libgbee-test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG840F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\efm32-common\CMSIS\Include; ..\common\EFM32TG\Include; ..\..\efm32-common\emlib\inc; ..\common\drivers; ..\common\bsp; $PROJ_DIR$; ..\..\libgbee\0.3.1\libgbee\src; ..\..\libgbee\0.3.1\libgbee\src\port\energymicro\tg; ..\..\xbee_if\; ..\..\ehm-common\; ..\..\efm32-common\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\common\CMSIS\Include; ..\common\EFM32TG\Include; ..\common\emlib\inc; ..\common\drivers; ..\common\bsp
  OBJCOPY.OOCOutputFile: libgbee-test.bin
  ILINK.IlinkOutputFile: libgbee-test.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32TG840F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCIncludePath2: ..\common\CMSIS\Include; ..\common\EFM32TG\Include; ..\common\emlib\inc; ..\common\drivers; ..\common\bsp; $PROJ_DIR$
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: cpp.out
  group Application
    ./: debug_output_control.h main.cpp
    ../../ehm-common/: messagetypes.h
    ../../xbee_if/: xbee_if.cpp xbee_if.h
  group EM framework/BSP
    ../common/bsp/: trace.c
  group EM framework/CMSIS
    ../common/EFM32TG/Source/: startup_efm32tg.s system_efm32tg.c
  group EM framework/Drivers
    ../../efm32-common/: dmamanager.cpp dmamanager.h uartmanager.cpp uartmanager.h uartport.cpp uartport.h
    ../common/drivers/: rtc.c
  group EM framework/emlib
    ../../efm32-common/emlib/src/: em_assert.c em_cmu.c em_dma.c em_emu.c em_gpio.c em_int.c em_leuart.c em_rtc.c em_system.c em_usart.c
  group libgbee
    ../../libgbee/0.3.1/libgbee/src/: gbee-port-interface.h gbee-util.c gbee-util.h gbee.c gbee.h
  group libgbee/port
    ../../libgbee/0.3.1/libgbee/src/port/energymicro/tg/: gbee-heap.c gbee-heap.h gbee-port.c gbee-port.h gbee-tick.c gbee-tick.h gbee-usart.cpp gbee-usart.h
