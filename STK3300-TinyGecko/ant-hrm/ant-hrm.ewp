# IAR project ant-hrm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; EFM32TG840F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\efm32-common\CMSIS\Include; ..\common\EFM32TG\Include; ..\..\efm32-common\emlib\inc; ..\common\drivers; ..\common\bsp; ..\..\efm32-common; $PROJ_DIR$; ..\..\ehm-common; ..\..\sensor
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\common\CMSIS\Include; ..\common\EFM32TG\Include; ..\common\emlib\inc; ..\common\drivers; ..\common\bsp
  OBJCOPY.OOCOutputFile: ant-hrm.bin
  ILINK.IlinkOutputFile: ant-hrm.out
  ILINK.IlinkIcfFile: ant-hrm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\common\CMSIS\Include; ..\common\EFM32TG\Include; ..\common\emlib\inc; ..\common\drivers; ..\common\bsp; $PROJ_DIR$
  ILINK.IlinkOutputFile: cpp.out
  group Application
    ../../efm32-common/: alarmmanager.cpp dmamanager.cpp ports_tg840f32.h
    ../../sensor/: anthrmsensor.cpp anthrmsensor.h sensor.cpp sensor.h
    ./: debug_output_control.h main.cpp
  group Application/ANT
    ../../sensor/ANT/: antdefines.h antmessage.h antplus.h hrm_rx.h
    ../../efm32-common/: leuartport.cpp leuartport.h uartport.cpp uartport.h usartmanager.cpp usartmanager.h usartport.cpp usartport.h
  group EM framework/BSP
    ../common/bsp/: trace.c
  group EM framework/CMSIS
    ../common/EFM32TG/Source/: startup_efm32tg.s system_efm32tg.c
  group EM framework/emlib
    ../../efm32-common/emlib/src/: em_assert.c em_cmu.c em_dma.c em_emu.c em_gpio.c em_int.c em_leuart.c em_rtc.c em_system.c em_usart.c
