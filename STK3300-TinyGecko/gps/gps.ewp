# IAR project gps.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\efm32-common\CMSIS\Include; ..\common\EFM32TG\Include; ..\..\efm32-common\emlib\inc; ..\common\drivers; ..\common\bsp; ..\..\efm32-common; $PROJ_DIR$; ..\..\ehm-common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\common\CMSIS\Include; ..\common\EFM32TG\Include; ..\common\emlib\inc; ..\common\drivers; ..\common\bsp
  OBJCOPY.OOCOutputFile: gps.bin
  ILINK.IlinkOutputFile: gps.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32TG840F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCIncludePath2: ..\common\CMSIS\Include; ..\common\EFM32TG\Include; ..\common\emlib\inc; ..\common\drivers; ..\common\bsp; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: cpp.out
  group Application
    ./: debug_output_control.h gpssensor.cpp main.cpp sensor.cpp sensor.h
    ../../efm32-common/: dmamanager.cpp uartmanager.cpp
  group EM framework/BSP
    ../common/bsp/: trace.c
  group EM framework/CMSIS
    ../common/EFM32TG/Source/: startup_efm32tg.s system_efm32tg.c
  group EM framework/Drivers
    ../common/drivers/: rtc.c
    ../../efm32-common/: uartport.cpp uartport.h
  group EM framework/emlib
    ../../efm32-common/emlib/src/: em_assert.c em_cmu.c em_dma.c em_emu.c em_gpio.c em_int.c em_leuart.c em_rtc.c em_system.c em_usart.c
