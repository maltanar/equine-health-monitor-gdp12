# IAR project integration.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG990F1024 EnergyMicro EFM32GG990F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\efm32-common\CMSIS\Include; ..\common\Device\EnergyMicro\EFM32GG\Include; ..\..\efm32-common\emlib\inc; ..\common\drivers; ..\common\bsp; ..\..\libgbee\0.3.1\libgbee\src; ..\..\libgbee\0.3.1\libgbee\src\port\energymicro\tg; ..\..\xbee_if\; ..\..\ehm-common\; ..\..\efm32-common\; ..\..\sensor; ..\..\fatfs; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\STK3300-TinyGecko\common\CMSIS\Include; ..\common\Device\EnergyMicro\EFM32GG\Include; ..\..\STK3300-TinyGecko\common\emlib\inc; ..\common\drivers; ..\..\STK3300-TinyGecko\common\bsp
  OBJCOPY.OOCOutputFile: integration.bin
  ILINK.IlinkOutputFile: integration.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32GG990F1024.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group bsp
    ../common/bsp/: dvk.c dvk_ebi.c dvk_spi.c trace.c
  group CMSIS
    ../common/Device/EnergyMicro/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../common/Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group efm32-common
    ../../efm32-common/: alarmmanager.cpp alarmmanager.h dmamanager.cpp dmamanager.h i2cbus.cpp i2cbus.h i2cmanager.h leuartport.cpp leuartport.h rtc.c rtc.h uartport.cpp uartport.h usartmanager.cpp usartmanager.h usartport.cpp usartport.h
  group emlib
    ../../efm32-common/emlib/src/: em_assert.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_leuart.c em_rtc.c em_system.c em_usart.c
  group fatfs
    ../../fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h microsd.c microsd.h
  group libgbee
    ../../libgbee/0.3.1/libgbee/src/: gbee-port-interface.h gbee-util.c gbee-util.h gbee.c gbee.h
    ../../xbee_if/: xbee_if.cpp xbee_if.h
  group libgbee/port
    ../../libgbee/0.3.1/libgbee/src/port/energymicro/tg/: gbee-heap.c gbee-heap.h gbee-port.cpp gbee-port.h gbee-tick.c gbee-tick.h gbee-usart.cpp gbee-usart.h
  group sensor
    ../../sensor/: accelerationsensor.cpp accelerationsensor.h gpssensor.cpp gpssensor.h sensor.cpp sensor.h temperaturesensor.cpp temperaturesensor.h
  group Source
    ./: debug_output_control.h integration.cpp
    ../../efm32-common/: ports_gg990f1024.h
