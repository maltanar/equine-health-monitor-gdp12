<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADXL350UnitTest.ewp</path>
  </project>
  <batchBuild/>
</workspace>


