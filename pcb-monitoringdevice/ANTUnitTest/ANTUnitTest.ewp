# IAR project ANTUnitTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG332F1024 EnergyMicro EFM32GG332F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG332F1024; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\efm32-common\CMSIS\Include; ..\common\Device\EnergyMicro\EFM32GG\Include; ..\..\efm32-common\emlib\inc; ..\common\bsp; ..\..\libgbee\0.3.1\libgbee\src; ..\..\libgbee\0.3.1\libgbee\src\port\energymicro\tg; ..\..\xbee_if\; ..\..\ehm-common\; ..\..\efm32-common\; ..\..\sensor; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\common\Device\EnergyMicro\EFM32GG\Include
  OBJCOPY.OOCOutputFile: integration.bin
  ILINK.IlinkOutputFile: integration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../common/bsp/: trace.c
  group CMSIS
    ../common/Device/EnergyMicro/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../common/Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group efm32-common
    ../../efm32-common/: alarmmanager.cpp alarmmanager.h dmamanager.cpp dmamanager.h i2cbus.cpp i2cbus.h i2cmanager.h i2sport.cpp i2sport.h leuartport.cpp leuartport.h spiport.cpp spiport.h uartport.cpp uartport.h usartmanager.cpp usartmanager.h usartport.cpp usartport.h
  group emlib
    ../../efm32-common/emlib/src/: em_assert.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_leuart.c em_rtc.c em_system.c em_usart.c
  group sensor
    ../../sensor/: accelerationsensor.cpp accelerationsensor.h anthrmsensor.cpp anthrmsensor.h gpssensor.cpp gpssensor.h sensor.cpp sensor.h temperaturesensor.cpp temperaturesensor.h
  group Source
    ./: ANTUnitTest.cpp debug_output_control.h
    ../../efm32-common/: port_config.h ports_gg332f1024.h
